# Keil uVision project Template.uvprojx, settings and files
target Template (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\DRIVER\inc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group USER
    ./: main.c stm32f10x_it.c
    ../DRIVER/src/: timer.c
